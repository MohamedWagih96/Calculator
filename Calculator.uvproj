# Keil uVision project Calculator.uvproj, settings and files
target Calculator (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: InputOutput
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Delay.c Documentation.c initialization.c prototypes.h appendDigit.c keypad_getkey.c keypad_init.c equal.c operation.c displayEquation.c reset.c keypadMap.c PortF_Output.c PortF_Init.c del.c cursorLocationMap.c moveCursor.c PortF_Input.c main.c
    ../inc/: tm4c123gh6pm.h
  group Object
    ./: texas.o
